# Keil uVision project MB1C6U111.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MB1C6U111 +hex
  AfterMake: fromelf --bin .\Obj\MB1C6U111.axf --output .\Obj\MB1C6U111.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x7e000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Start
    ./Start/: startup_LPC17xx.s system_LPC17xx.c
  group Config
    ./Config/: RTX_Config.c
  group Drivers
    ./Drivers/: ADconvert.c Att7022eu.c CAN.c Dataflash.c Delay.c IRIGB.c key.c Lcd.c PinConfig.c Relay.c Rtc.c Switch.c uart_device.c Usb.c Wdt.c
  group Tasks
    ./Tasks/: Att7022euTask.c Backstage.c BackstageTable.c BatteryManage.c BSCdt.c BSModbus.c CanComm.c CanDCDCComm.c Com1Comm.c CompareTime.c Crc.c DCcollect.c Display.c DisplayString.c Encry.c Fault.c FaultId.c FetchFlash.c KeyTask.c LoadFile.c Log.c Main.c PublicData.c SwitchTsak.c WdtTask.c BSInternal.c
